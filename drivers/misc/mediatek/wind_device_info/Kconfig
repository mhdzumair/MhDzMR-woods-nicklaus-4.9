## drivers/misc/mediatek/wind_device_info/Kconfig
```kconfig
config WIND_DEVICE_INFO
	bool "CONFIG_WIND_DEVICE_INFO"
	default n
	help
		Select y or n
```
